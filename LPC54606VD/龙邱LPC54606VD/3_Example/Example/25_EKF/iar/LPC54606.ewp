# IAR project LPC54606.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: LPC54606J512 NXP LPC54606J512
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; _DLIB_FILE_DESCRIPTOR; CPU_LPC54606; CPU_LPC54606J512BD100=1; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=1
  ICCARM.CCDiagSuppress: Pa082,
  ICCARM.CCIncludePath2: ..; ..\..\..\CMSIS\Include; ..\..\..\Drivers\board; ..\..\..\Drivers\drivers\FSL_LPC54606; ..\..\..\Drivers\drivers\LQ_LPC54606; ..\..\..\Drivers\startup\iar; ..\..\..\Drivers\utilities; ..\..\..\Drivers; ..\..\..\Drivers\drivers\LQ_LPC54606\test; ..\..\..\Drivers\drivers\LQ_LPC54606\peripheral
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LPC54606.srec
  ILINK.IlinkOutputFile: LPC54606.out
  ILINK.IlinkIcfFile: ..\..\..\Drivers\startup\iar\LPC54606J512_flash.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\Drivers\startup\iar\iar_lib_power.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group board
    ../../../Drivers/board/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group doc
    ../: readme.txt
  group drivers
    ../../../Drivers/drivers/FSL_LPC54606/: fsl_adc.c fsl_adc.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_ctimer.c fsl_ctimer.h fsl_dma.c fsl_dma.h fsl_eeprom.c fsl_eeprom.h fsl_flashiap.c fsl_flashiap.h fsl_flexcomm.c fsl_flexcomm.h fsl_gint.c fsl_gint.h fsl_gpio.c fsl_gpio.h fsl_i2c.c fsl_i2c.h fsl_inputmux.c fsl_inputmux.h fsl_inputmux_connections.h fsl_iocon.h fsl_mrt.c fsl_mrt.h fsl_otp.h fsl_pint.c fsl_pint.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_rit.c fsl_rit.h fsl_sctimer.c fsl_sctimer.h fsl_spi.c fsl_spi.h fsl_usart.c fsl_usart.h fsl_usart_dma.c fsl_usart_dma.h fsl_wwdt.c fsl_wwdt.h
  group imu
    ../: AP_Math.c AP_Math.h ComplementaryFilter.c ComplementaryFilter.h EKF.c EKF.h Inertial_Sensor.c Inertial_Sensor.h
  group lpc54606
    ../../../Drivers/drivers/LQ_LPC54606/: LQ_ADC.c LQ_ADC.h LQ_CTIME.c LQ_CTIME.h LQ_DMA.c LQ_DMA.h LQ_EEPROM.c LQ_EEPROM.h LQ_GPIO.c LQ_GPIO.h LQ_IIC.c LQ_IIC.h LQ_MRT.c LQ_MRT.h LQ_RIT.c LQ_RIT.h LQ_SCTIME.c LQ_SCTIME.h LQ_SOFTIIC.c LQ_SOFTIIC.h LQ_SOFTSPI.c LQ_SOFTSPI.h LQ_SPI.c LQ_SPI.h LQ_SYSTICK.c LQ_SYSTICK.h LQ_UART.c LQ_UART.h LQ_UART_DMA.c LQ_UART_DMA.h LQ_WDOG.c LQ_WDOG.h
  group peripheral
    ../../../Drivers/drivers/LQ_LPC54606/peripheral/: ANO_DT.c ANO_DT.h LQ_12864.h LQ_12864SPI.c LQ_9AX.c LQ_9AX.h LQ_CAMERA.c LQ_CAMERA.h LQ_ICM20602.c LQ_ICM20602.h LQ_KEY.c LQ_KEY.h LQ_LED.c LQ_LED.h LQ_MPU6050.c LQ_MPU6050.h LQ_MT9V034.c LQ_MT9V034.h LQ_PROTOCOL.c LQ_PROTOCOL.h LQ_SGP18T.c LQ_SGP18T.h
  group source
    ../: config.h include.h irq.c main.c
  group startup
    ../../../Drivers/startup/iar/: startup_LPC54606.s
    ../../../Drivers/: system_LPC54606.c
  group Test
    ../../../Drivers/drivers/LQ_LPC54606/test/: TEST_9AX.c TEST_9AX.h TEST_ADC.c TEST_ADC.h TEST_CAMERA.c TEST_CAMERA.h TEST_EEPROM.c TEST_EEPROM.h TEST_ENC.c TEST_ENC.h TEST_ICM20602.c TEST_ICM20602.h TEST_MPU6050.c TEST_MPU6050.h TEST_MRT.c TEST_MRT.h TEST_PWM.c TEST_PWM.h TEST_RIT.c TEST_RIT.h TEST_SYSTICK.c TEST_SYSTICK.h TEST_UART.c TEST_UART.h TEST_Ultrasonic.c TEST_Ultrasonic.h TEST_VL53.c TEST_VL53.h TEST_WDog.c TEST_WDog.h
  group utilities
    ../../../Drivers/utilities/: fsl_assert.c fsl_debug_console.c fsl_str.c generic_list.c serial_manager.c serial_port_uart.c usart_adapter.c
