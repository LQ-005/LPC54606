# Keil uVision project LPC54606.uvprojx, settings and files
target Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC54606J512BD208:M4 NXP
  pack: Keil.LPC54000_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00028000) IRAM2(0x04000000,0x00008000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LPC54606
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: _DLIB_FILE_DESCRIPTOR,DEBUG, CPU_LPC54606, CPU_LPC54606J512BD100=1,PRINTF_FLOAT_ENABLE=1,SCANF_FLOAT_ENABLE=1,PRINTF_ADVANCED_ENABLE=1,SCANF_ADVANCED_ENABLE=1,
  c misc: --library_interface=armcc --diag_suppress=1296,186,1,66
  c include: ..\..\25_EKF;..\..\..\CMSIS\Include;..\..\..\Drivers\board;..\..\..\Drivers\drivers\FSL_LPC54606;..\..\..\Drivers\drivers\LQ_LPC54606;..\..\..\Drivers\startup\arm;..\..\..\Drivers\utilities;..\..\..\Drivers;..\..\..\Drivers\drivers\LQ_LPC54606\test;..\..\..\Drivers\drivers\LQ_LPC54606\peripheral
  asm define: DEBUG,__CC_ARM,KEIL, DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: ..\..\..\Drivers\startup\arm\LPC54606J512_flash.scf
  link misc: ../../../Drivers\startup\arm/keil_lib_power.lib --remove
  group source
    ../: main.c config.h include.h irq.c
  group lpc54606
    ../../../Drivers/drivers/LQ_LPC54606/: LQ_ADC.c LQ_CTIME.c LQ_DMA.c LQ_EEPROM.c LQ_GPIO.c LQ_IIC.c LQ_MRT.c LQ_RIT.c LQ_SCTIME.c LQ_SOFTIIC.c LQ_SOFTSPI.c LQ_SPI.c LQ_SYSTICK.c LQ_UART.c LQ_UART_DMA.c LQ_WDOG.c
  group peripheral
    ../../../Drivers/drivers/LQ_LPC54606/peripheral/: ANO_DT.c LQ_9AX.c LQ_12864SPI.c LQ_CAMERA.c LQ_ICM20602.c LQ_KEY.c LQ_LED.c LQ_MPU6050.c LQ_MT9V034.c LQ_SGP18T.c LQ_PROTOCOL.c
  group imu
    ../: AP_Math.c ComplementaryFilter.c EKF.c Inertial_Sensor.c LowPassFilter.c
  group test
    ../../../Drivers/drivers/LQ_LPC54606/test/: TEST_MRT.c TEST_RIT.c TEST_UART.c TEST_SYSTICK.c TEST_ADC.c TEST_WDog.c TEST_MPU6050.c TEST_9AX.c TEST_VL53.c TEST_Ultrasonic.c TEST_ICM20602.c TEST_EEPROM.c TEST_CAMERA.c TEST_ENC.c TEST_PWM.c
  group drivers
    ../../../Drivers/drivers/FSL_LPC54606/: fsl_adc.c fsl_clock.c fsl_common.c fsl_ctimer.c fsl_dma.c fsl_eeprom.c fsl_flashiap.c fsl_flexcomm.c fsl_gint.c fsl_gpio.c fsl_i2c.c fsl_inputmux.c fsl_mrt.c fsl_pint.c fsl_power.c fsl_reset.c fsl_rit.c fsl_sctimer.c fsl_spi.c fsl_usart.c fsl_usart_dma.c fsl_wwdt.c
  group board
    ../../../Drivers/board/: board.c clock_config.c pin_mux.c
  group startup
    ../../../Drivers/: system_LPC54606.c
    ../../../Drivers/startup/arm/: startup_LPC54606.s
  group utilities
    ../../../Drivers/utilities/: fsl_assert.c fsl_debug_console.c fsl_str.c generic_list.c serial_manager.c serial_port_uart.c usart_adapter.c
  group doc
    ../: readme.txt
